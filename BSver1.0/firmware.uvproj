# Keil uVision project firmware.uvproj, settings and files
target БС 79511901 (166/167)
  device: 1887VE3T Generic
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xD800-0xE7FF) IROM(0x000000-0x07FFF) IROM2(0x018000-0x04FFFF) CLOCK(20000000) MOD167
  output: BS_79511901 +hex
  group ProjectFiles
    ./: START_V2.A66 asmbsl.a66 main.c process.c
    ./vers/: vers79511901.c vers79511902.c
  group Protocol
    ./: protocol.c devices.c
  group Drivers
    ./: can.c settings.c asc0.c flash.c system.c bsl.c
  group Devices
    ./: bdmg.c bdgp.c bdsp.c
target БС 79511902 (166/167)
  device: 1887VE3T Generic
  cpu: as above
  output: BS_79511902 +hex
